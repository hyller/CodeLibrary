# Keil uVision project example.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2214/01 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40003FFF) IROM(0-0x3FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: example +hex
  c flags: Optim=1 wLevel=1
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT6: RAM 0x80000000 size 0x20000
  memory RVCT9: RAM 0x40000000 size 0x4000
  group Main
    ./: Startup.s ISR.s PeripherialInit.s BSP.cpp main.cpp
  group EmbeddedGUI
    ./: EControl.cpp ECursor.cpp GraphicFunc.cpp LCDDriver.cpp EFrame.cpp
