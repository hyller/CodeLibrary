# IAR project zboss_sniffer.ewp, settings and files
configuration SmartRf05Eb-Debug (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2530F256.i51
  ICC8051.CCDefines: ZB_SNIFFER_IAR; ZB_SNIFFER_CC2530
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: usb\common; usb\common\cc8051; usb\class_cdc; usb\library; usb\library\cc2531; usb\targets\srf05soc; usb\targets\common; usb\targets\interface; usb\utils
  ICC8051.CCStdIncludePath: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  ICC8051.CCOptLevel: 1
  ICC8051.CCOptStrategy: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\lnk51ew_cc2530F256_banked.xcl
configuration Smartrf05Eb-Release (8051)
  as the first configuration, except:
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\lnk51ew_CC2530F256_banked.xcl
configuration CC2531-USB-Dongle-Debug (8051, debug)
  as the first configuration, except:
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2531F256.i51
  ICC8051.CCDefines: ZB_SNIFFER_IAR; ZB_SNIFFER_CC2531
  ICC8051.CCIncludePath2: $PROJ_DIR$; usb\common; usb\common\cc8051; usb\class_cdc; usb\library; usb\library\cc2531; usb\targets\cc2531_dongle; usb\targets\common; usb\targets\interface; usb\utils
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\lnk51ew_cc2531F256.xcl
configuration CC2531-USB-Dongle-Release (8051)
  as the first configuration, except:
  General.DerivativeDescriptionFile: as above
  ICC8051.CCDefines: ZB_SNIFFER_CC2531; ZB_SNIFFER_IAR
  ICC8051.CCIncludePath2: as above
  XLINK.XclFile: as above
  group sniffer
    ./: zb_sniffer.c zb_sniffer_leds.c zb_sniffer_radio.c zb_sniffer_rs232.c zb_sniffer_time.c zb_sniffer_transport.c
  group usb
    ./: zb_sniffer_usb.c
  group usb/class_cdc
    usb/class_cdc/: usb_cdc_descriptor.s51 usb_cdc_hooks.c usb_firmware_library_config.c usb_uart.c
  group usb/library
    usb/library/: usb_descriptor_parser.c usb_framework.c usb_standard_requests.c
  group usb/library/cc2531
    usb/library/cc2531/: hal_enter_pm.s51 usb_interrupt.c usb_suspend.c
