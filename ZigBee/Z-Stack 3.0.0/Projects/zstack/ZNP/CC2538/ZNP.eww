<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\ZNP.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>ZNP</project>
        <configuration>cc2538</configuration>
      </member>
      <member>
        <project>ZNP</project>
        <configuration>cc2538-SBL</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


