# Keil uVision project Project.uvprojx, settings and files
target STM3210E_EVAL (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103ZG STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0x8000000-0x80FFFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM3210E_EVAL
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xG,USE_STM3210E_EVAL
  c misc: --C99
  c include: ../Inc;../../../../../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../../../../../Drivers/STM32F1xx_HAL_Driver/Inc;../../../../../Drivers/BSP/STM3210E_EVAL;../../../../../Drivers/BSP/Components/Common;../../../../../Utilities/Log;../../../../../Utilities/CPU
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  link misc: --diag_suppress=L6329
  group Example/Utilities
    ../../../../../Utilities/Log/: lcd_log.c
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group Example/User
    ../Src/: temperature_sensor.c main.c nand.c audio_play.c nor.c stm32f1xx_it.c lcd.c joystick.c flash.c sd.c sram.c log.c
  group Drivers/BSP/STM3210E_EVAL
    ../../../../../Drivers/BSP/STM3210E_EVAL/: stm3210e_eval_nand.c stm3210e_eval_tsensor.c stm3210e_eval.c stm3210e_eval_audio.c stm3210e_eval_lcd.c stm3210e_eval_nor.c stm3210e_eval_sd.c stm3210e_eval_serialflash.c stm3210e_eval_sram.c
  group Example/MDK-ARM
    ./: startup_stm32f103xg.s
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components
    ../../../../../Drivers/BSP/Components/stlm75/: stlm75.c
    ../../../../../Drivers/BSP/Components/hx8347d/: hx8347d.c
    ../../../../../Drivers/BSP/Components/spfd5408/: spfd5408.c
    ../../../../../Drivers/BSP/Components/ili9320/: ili9320.c
    ../../../../../Drivers/BSP/Components/ak4343/: ak4343.c
  group Drivers/STM32F1xx_HAL_Driver
    ../../../../../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_tim.c stm32f1xx_hal_cortex.c stm32f1xx_hal_rcc.c stm32f1xx_hal_nand.c stm32f1xx_hal_pwr.c stm32f1xx_hal_spi_ex.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_gpio.c stm32f1xx_hal_sram.c stm32f1xx_ll_fsmc.c stm32f1xx_hal_i2c.c stm32f1xx_hal_i2s.c stm32f1xx_hal_dma.c stm32f1xx_hal_rcc_ex.c stm32f1xx_ll_sdmmc.c stm32f1xx_hal_sd.c stm32f1xx_hal_adc.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal.c stm32f1xx_hal_nor.c
software components: CMSIS:CORE 4.1.0
