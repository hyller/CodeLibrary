# Keil uVision project Project.uvprojx, settings and files
target STM3210C_EVAL (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: STM3210C_EVAL
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F107xC,USE_STM3210C_EVAL
  c misc: --C99
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../../../../../../Drivers/STM32F1xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM3210C_EVAL
  library: MicroLIB
  link misc: --diag_suppress=L6329
  group Doc
    ../: readme.txt
  group Example/MDK-ARM
    ./: startup_stm32f107xc.s
  group Drivers/STM32F1xx_HAL_Driver
    ../../../../../../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_dac_ex.c stm32f1xx_hal_rcc.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_cortex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_dac.c stm32f1xx_hal_tim.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal.c stm32f1xx_hal_adc.c stm32f1xx_hal_uart.c stm32f1xx_hal_dma.c
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group Drivers/BSP/STM3210C_EVAL
    ../../../../../../Drivers/BSP/STM3210C_EVAL/: stm3210c_eval.c
  group Example/User
    ../Src/: stm32f1xx_hal_msp.c stm32f1xx_it.c main.c
software components: CMSIS:CORE 4.1.0
